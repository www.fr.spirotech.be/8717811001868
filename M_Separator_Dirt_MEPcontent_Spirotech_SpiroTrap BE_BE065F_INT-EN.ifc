Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_BE065F_INT-EN.ifc
Time: 2025-08-05T18:27:57+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2005224_1
Port_2005224_2

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN:BE065F, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN:BE065F:2005224
In: F00
Type - Material: Color RGB 168-128-048, Color RGB 128-128-128, Color RGB 198-000-000, Color RAL 1003
Type - Other - Category: Pipe Accessories; Air Vent Offset: 2.5 mm; Air vent visible: yes; Chamfer Radius: 31.8 mm; Connection Diameter: 65 mm; Connector Length: 350 mm; Diameter: 159 mm; Dist B: 3 mm; Dist C: 15 mm; Drain 1: no; Drain 2: yes; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN; h1 second: 120 mm; h2: 94 mm; h3: 41.8 mm; Handel Offset: 137 mm; Offset front rings: 236 mm; Radius: 38.05 mm; Radius A: 92.5 mm; Radius B: 61 mm; Rings: no; Rings Offset: 12 mm; Ring Visibility: yes
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 65 mm; Connection Outer Diameter: 76.1 mm; H: 364 mm; h1: 244 mm; L: 260 mm; LF: 350 mm; Use Nominal Diameter: yes
Type - General - Annual Maintenance: Drain dirt from unit
Type - Identity Data - Article Description: Dirt separator - Steel - Flange DN65; Article Type: BE065F; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Dirt separator - Steel - Flange DN65; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811001837; Manufacturer: Spirotech; Manufacturer Art. No.: BE065F; Manufacturer URL: https://www.spirotech.com/8717811001837; MEPcontent Class: SEPARATOR_DIRT; Model: BE065F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BE065F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Brass Yellow: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.03417 m3/s; Pressure Stage: PN16
Type - Mechanical - Flow - Kv: 0.03417 m3/s
Type - Visibility - Flange Connection: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BE065F; sets with these values: 2
Other - Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN: BE065F; Type: BE065F; Type Id: 2005190
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 65 mm; Minimum Size: 65 mm; Volume: 0.00941248 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
