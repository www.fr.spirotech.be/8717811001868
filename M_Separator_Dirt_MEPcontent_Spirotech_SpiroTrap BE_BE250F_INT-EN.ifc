Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_BE250F_INT-EN.ifc
Time: 2025-08-05T18:27:38+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2005212_1
Port_2005212_2

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN:BE250F, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN:BE250F:2005212
In: F00
Type - Material: Color RAL 1003, Color RGB 168-128-048, Color RGB 128-128-128, Color RGB 198-000-000
Type - Other - Category: Pipe Accessories; Air Vent Offset: 18 mm; Air vent visible: no; Chamfer Radius: 101.6 mm; Connection Diameter: 250 mm; Connector Length: 890 mm; Diameter: 508 mm; Dist B: 3 mm; Dist C: 15 mm; Drain 1: yes; Drain 2: no; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN; h1 second: 344 mm; h2: 150 mm; h3: 111.6 mm; Handel Offset: 408 mm; Offset front rings: 794 mm; Radius: 136.5 mm; Radius A: 202.5 mm; Radius B: 160 mm; Rings: yes; Rings Offset: 18 mm; Ring Visibility: yes
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 250 mm; Connection Outer Diameter: 273 mm; H: 1106 mm; h1: 0.0082021 mm; L: 750 mm; LF: 890 mm; Use Nominal Diameter: yes
Type - General - Annual Maintenance: Drain dirt from unit
Type - Identity Data - Article Description: Dirt separator - Steel - Flange DN250; Article Type: BE250F; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Dirt separator - Steel - Flange DN250; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811002056; Manufacturer: Spirotech; Manufacturer Art. No.: BE250F; Manufacturer URL: https://www.spirotech.com/8717811002056; MEPcontent Class: SEPARATOR_DIRT; Model: BE250F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BE250F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Brass Yellow: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.32111 m3/s; Pressure Stage: PN16
Type - Mechanical - Flow - Kv: 0.32111 m3/s
Type - Visibility - Flange Connection: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BE250F; sets with these values: 2
Other - Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN: BE250F; Type: BE250F; Type Id: 2005166
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 250 mm; Minimum Size: 250 mm; Volume: 0.237823 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
