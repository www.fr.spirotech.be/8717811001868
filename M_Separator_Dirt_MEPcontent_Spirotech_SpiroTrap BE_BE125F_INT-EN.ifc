Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_BE125F_INT-EN.ifc
Time: 2025-08-05T18:27:49+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2005218_1
Port_2005218_2

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN:BE125F, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN:BE125F:2005218
In: F00
Type - Material: Color RGB 168-128-048, Color RGB 128-128-128, Color RGB 198-000-000, Color RAL 1003
Type - Other - Category: Pipe Accessories; Air Vent Offset: 2.5 mm; Air vent visible: yes; Chamfer Radius: 64.8 mm; Connection Diameter: 125 mm; Connector Length: 635 mm; Diameter: 324 mm; Dist B: 3 mm; Dist C: 15 mm; Drain 1: no; Drain 2: yes; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN; h1 second: 185 mm; h2: 93 mm; h3: 74.8 mm; Handel Offset: 299 mm; Offset front rings: 236 mm; Radius: 69.85 mm; Radius A: 125 mm; Radius B: 94 mm; Rings: no; Rings Offset: 30 mm; Ring Visibility: yes
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 125 mm; Connection Outer Diameter: 139.7 mm; H: 639 mm; h1: 454 mm; L: 525 mm; LF: 635 mm; Use Nominal Diameter: yes
Type - General - Annual Maintenance: Drain dirt from unit
Type - Identity Data - Article Description: Dirt separator - Steel - Flange DN125; Article Type: BE125F; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Dirt separator - Steel - Flange DN125; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811001950; Manufacturer: Spirotech; Manufacturer Art. No.: BE125F; Manufacturer URL: https://www.spirotech.com/8717811001950; MEPcontent Class: SEPARATOR_DIRT; Model: BE125F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BE125F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Brass Yellow: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.10306 m3/s; Pressure Stage: PN16
Type - Mechanical - Flow - Kv: 0.10306 m3/s
Type - Visibility - Flange Connection: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BE125F; sets with these values: 2
Other - Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap BE_INT-EN: BE125F; Type: BE125F; Type Id: 2005178
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 125 mm; Minimum Size: 125 mm; Volume: 0.0567909 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
